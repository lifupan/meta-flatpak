BBCLASSEXTEND_append = " native"

DEPENDS_append_class-native = " glib-networking-native "
